FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-wifi_mod_para.conf-change-fw-to-enable-sdio-BT.patch"
