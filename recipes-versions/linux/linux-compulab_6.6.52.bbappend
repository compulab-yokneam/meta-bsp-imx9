SRCBRANCH = "linux-compulab_v6.6.52-rt-iot-link-1.0.1"
SRCREV = "b932966e262957fd1e26d577a017871f3007a45d"
